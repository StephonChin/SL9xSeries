# Keil uVision project AL-Curtain.uvprojx, settings and files
target AL-Curtain (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: Mini58FDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: AL-Curtain +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\PrivateInc;..\Public\PublicInc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group PublicSrc
    ../Public/PublicSrc/: BT_Control.c CSR1010.c Data_Process.c Display_Ctrl.c Flash_Prgrm.c Led_Class.c MCU_Config.c Music.c ShowHomeApp.c Timer_Ctrl.c
  group PublicInc
    ../Public/PublicInc/: BT_Control.h CSR1010.h Data_Process.h Display_Ctrl.h Flash_Prgrm.h Led_Class.h MCU_Config.h Mini58Series.h Music.h ShowHomeApp.h Timer_Ctrl.h Type_Def.h
  group PrivateSrc
    ./PrivateSrc/: Normal_Display.c Show_1.c Show_2.c Show_3.c
  group PrivateInc
    ./PrivateInc/: Type_Private.h
software components: CMSIS:CORE 5.0.2, Device:Driver:CLK 3.00.003, Device:Driver:FMC 3.00.003, Device:Driver:GPIO 3.00.003, Device:Driver:PWM 3.00.003, Device:Driver:SYS 3.00.003, Device:Driver:Timer 3.00.003, Device:Driver:UART 3.00.003, Device:Driver:WDT 3.00.003, Device:Startup 3.00.003
