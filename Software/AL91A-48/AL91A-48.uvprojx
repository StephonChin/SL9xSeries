# Keil uVision project AL91A-48.uvprojx, settings and files
target AL91A-48 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: Mini58FDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: AL91A-48 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\PrivateInc;..\Public\PublicInc;..\AL91Pulic;..\FwLib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group PrivateSrc
    ../AL91Pulic/: Normal_Display.c Show_1.c Show_2.c Show_3.c
  group PrivateInc
    ./PrivateInc/: Type_Private.h
  group PublicSrc
    ../Public/PublicSrc/: ShowHomeApp.c MCU_Config.c BT_Control.c Data_Process.c CSR1010.c Display_Ctrl.c Led_Class.c Flash_Prgrm.c Timer_Ctrl.c Music.c
  group PublicInc
    ../Public/PublicInc/: ShowHomeApp.h MCU_Config.h BT_Control.h Data_Process.h CSR1010.h Display_Ctrl.h Led_Class.h Flash_Prgrm.h Timer_Ctrl.h Type_Def.h Music.h
  group FwLib
    ../FwLib/src/: clk.c gpio.c pwm.c sys.c timer.c uart.c fmc.c
    ../FwLib/inc/: clk.h gpio.h pwm.h sys.h timer.h uart.h fmc.h
software components: CMSIS:CORE 4.3.0, Device:Startup 3.00.003
