# Keil uVision project AL96.uvprojx, settings and files
target AL96 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: Mini58LDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: AL96 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\PrivateInc;..\FwLib\inc;..\Public\PublicInc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group PrivateSrc
    ./PrivateSrc/: Key.c Normal_Display.c Sleep.c
    ../AL92Public/: Show_1.c Show_2.c Show_3.c
  group PrivateInc
    ./PrivateInc/: Key.h Type_Private.h Sleep.h
  group PublicSrc
    ../Public/PublicSrc/: CSR1010.c Data_Process.c Display_Ctrl.c Flash_Prgrm.c Led_Class.c MCU_Config.c ShowHomeApp.c Timer_Ctrl.c BT_Control.c Music.c
  group PublicInc
    ../Public/PublicInc/: CSR1010.h Data_Process.h Display_Ctrl.h Flash_Prgrm.h Led_Class.h MCU_Config.h Mini58Series.h ShowHomeApp.h Timer_Ctrl.h Type_Def.h BT_Control.h Music.h
  group FwLib
    ../FwLib/src/: clk.c fmc.c gpio.c pwm.c sys.c timer.c uart.c wdt.c
    ../FwLib/inc/: clk.h fmc.h gpio.h pwm.h sys.h timer.h uart.h
software components: CMSIS:CORE 4.3.0, Device:Startup 3.00.003
